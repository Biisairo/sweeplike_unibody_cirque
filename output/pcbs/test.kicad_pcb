File: output/pcbs/test.kicad_pcb (KiCad board)
At the start: 2 copper layers, 379.3 x 127.2 mm, 0 parts

Commit message: second commit
Other:
- board size 379.3 x 127.2 mm -> 375.4 x 123.6 mm
